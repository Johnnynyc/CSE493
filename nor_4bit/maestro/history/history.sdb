<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Nov 8 20:36:31 2024</timestamp>
			<uuid>{530e45a6-66f9-4110-94dc-e1ad68fbc161}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/shared/projects/CSE493/team-h/KoggeStone_ALU/nor_4bit/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/shared/projects/CSE493/team-h/KoggeStone_ALU/nor_4bit/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/eng/home/njfox4/cse493_593/simulations/KoggeStone_ALU/nor_4bit/maestro/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/eng/home/njfox4/cse493_593/simulations/KoggeStone_ALU/nor_4bit/maestro/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
	</history>
</setupdb>

<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Nov 8 18:26:09 2024</timestamp>
			<uuid>{e824e6f4-07d3-478b-bfea-de1576569bd6}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsisuserpath>1</resultsisuserpath>
			<resultspsfisuserpath>1</resultspsfisuserpath>
			<resultsname>/eng/home/jiehanke/cse493_593/project/4b_SLL/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>./project/4b_SLL/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/eng/home/jiehanke/cse493_593/project/4b_SLL/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>./project/4b_SLL/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/eng/home/jiehanke/cse493_593/simulations/project/4b_SLL/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>~/cse493_593/simulations/project/4b_SLL/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
